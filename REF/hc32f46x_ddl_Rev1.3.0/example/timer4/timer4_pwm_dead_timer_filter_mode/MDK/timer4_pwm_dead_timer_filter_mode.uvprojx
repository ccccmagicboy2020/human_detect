# Keil uVision project timer4_pwm_dead_timer_filter_mode.uvprojx, settings and files
target timer4_pwm_dead_timer_filter_mode_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer4_pwm_dead_timer_filter_mode
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x03000c00 size 0x3FC
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../../../mcu/common/: system_hc32f46x.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_timer4_cnt.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c
target timer4_pwm_dead_timer_filter_mode_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer4_pwm_dead_timer_filter_mode +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 4.1.0
