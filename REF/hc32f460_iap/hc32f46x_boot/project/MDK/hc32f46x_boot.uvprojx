# Keil uVision project hc32f46x_boot.uvprojx, settings and files
target hc32f46x_boot_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.1
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f46x_boot +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: HC32F46x
  c misc: --diag_suppress=186,66
  c include: ..\..\app\iap;..\..\common;..\..\driver;..\..\midware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../common/: system_hc32f46x.c hc32f46x_icg.c hc32f46x_gpio.c hc32f46x_gpio.h hc32f46x_timer0.c hc32f46x_timer0.h hc32f46x_utility.c hc32f46x_utility.h hc32f46x_interrupts.c hc32f46x_interrupts.h
  group source
    ../source/: main.c
  group driver
    ../../driver/: basic.c flash.c uart.c
  group app
    ../../app/iap/: iap.c modem.c User_Gpio.c User_Gpio.h User_Timer.c User_Timer.h
software components: CMSIS:CORE 5.0.1
