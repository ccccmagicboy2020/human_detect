# Keil uVision project hc32f46x_app.uvprojx, settings and files
target hc32f46x_app_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.1
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f46x_app +hex
  AfterMake: fromelf --bin !L --output hc32f46x_app.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\source;..\..\common;..\..\driver\inc;..\..\app
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x7c000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../common/: system_hc32f46x.c
  group source
    ../source/: main.c
    ../../app/: User_Gpio.c User_Gpio.h User_Timer.c User_Timer.h
  group driver
    ../../driver/src/: hc32f46x_gpio.c hc32f46x_utility.c hc32f46x_timer0.c hc32f46x_keyscan.c hc32f46x_interrupts.c
software components: CMSIS:CORE 5.0.1
