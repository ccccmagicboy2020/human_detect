# IAR project hc32f46x_app.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\common; ..\..\project\source; ..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f46x_app.bin
  ILINK.IlinkOutputFile: hc32f46x_app.out
  ILINK.IlinkIcfFile: config\HC32F46x_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  OBJCOPY.OOCOutputFile: hc32f46x_app.srec
  ILINK.IlinkIcfFile: hc32f46x.icf
  group common
    ./: startup_hc32f46x.s
    ../../common/: system_hc32f46x.c
  group driver
    ../../driver/src/: hc32f46x_gpio.c hc32f46x_utility.c
  group source
    ../source/: main.c
